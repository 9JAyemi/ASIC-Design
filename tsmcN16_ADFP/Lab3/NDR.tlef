VERSION 5.6 ; 
DIVIDERCHAR "/" ; 
BUSBITCHARS "[]" ; 
UNITS 
  DATABASE MICRONS 2000 ; 
END UNITS 
 
PROPERTYDEFINITIONS 
	NONDEFAULTRULE LEF58_USEVIACUTCLASS STRING ; 
END PROPERTYDEFINITIONS 
 
NONDEFAULTRULE TrunkNDR 
  LAYER M1 
     WIDTH 0.032 ; 
     SPACING 0.030 ; 
  END M1 
  LAYER M2 
    WIDTH 0.032 ; 
    SPACING 0.032 ; 
  END M2 
  LAYER M3 
    WIDTH 0.032 ; 
    SPACING 0.032 ; 
  END M3 
  LAYER M4
    WIDTH 0.040 ; 
    SPACING 0.040 ; 
  END M4 
  LAYER M5 
    WIDTH 0.040 ;
    SPACING 0.040 ; 
  END M5 
  LAYER M6 
    WIDTH 0.040 ; 
    SPACING 0.040 ;
  END M6 
  LAYER M7 
    WIDTH 0.040 ; 
    SPACING 0.040 ; 
  END M7 
  LAYER M8 
    WIDTH 0.124 ; 
    SPACING 0.128 ; 
  END M8  
  LAYER M9
    WIDTH 0.124 ;
    SPACING 0.128 ; 
  END M9
  LAYER M10 
    WIDTH 0.45 ;
    SPACING 0.45 ; 
  END M10
  LAYER M11 
    WIDTH 0.45 ;
    SPACING 0.45 ; 
  END M11
  LAYER AP 
    WIDTH 1.8000 ; 
    SPACING 1.800 ; 
  END AP 
END TrunkNDR 
NONDEFAULTRULE LeafNDR 
  LAYER M1 
     WIDTH 0.032 ; 
     SPACING 0.030 ; 
  END M1 
  LAYER M2 
    WIDTH 0.032 ; 
    SPACING 0.032 ; 
  END M2 
  LAYER M3 
    WIDTH 0.032 ; 
    SPACING 0.032 ; 
  END M3 
  LAYER M4
    WIDTH 0.040 ; 
    SPACING 0.080 ; 
  END M4 
  LAYER M5 
    WIDTH 0.040 ; 
    SPACING 0.080 ; 
  END M5 
  LAYER M6 
    WIDTH 0.040 ; 
    SPACING 0.080 ; 
  END M6 
  LAYER M7 
    WIDTH 0.040 ; 
    SPACING 0.080 ; 
  END M7 
  LAYER M8 
    WIDTH 0.062 ; 
    SPACING 0.064 ; 
  END M8 
  LAYER M9 
    WIDTH 0.062 ; 
    SPACING 0.064 ; 
  END M9
  LAYER M10 
    WIDTH 0.45 ; 
    SPACING 0.45 ; 
  END M10
  LAYER M11 
    WIDTH 0.45 ; 
    SPACING 0.45 ; 
  END M11
  LAYER AP 
    WIDTH 1.8000 ; 
    SPACING 1.800 ; 
  END AP 
END LeafNDR 
END LIBRARY
