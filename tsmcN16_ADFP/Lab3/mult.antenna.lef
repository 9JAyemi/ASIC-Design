

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO mult 
  PIN inp_a[15] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 60.132 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.897 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[15]
  PIN inp_a[14] 
    ANTENNAPARTIALMETALAREA 0.0678 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001695 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.3544 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0089 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M5 ; 
    ANTENNAMAXAREACAR 239.643 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 6.433 LAYER M5 ;
    ANTENNAMAXCUTCAR 3.36 LAYER VIA5 ;
  END inp_a[14]
  PIN inp_a[13] 
    ANTENNAPARTIALMETALAREA 0.0372 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00097 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 229.146 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 7.04783 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.096 LAYER VIA4 ;
  END inp_a[13]
  PIN inp_a[12] 
    ANTENNAPARTIALMETALAREA 0.05104 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001276 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 66.215 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.9545 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.048 LAYER VIA4 ;
  END inp_a[12]
  PIN inp_a[11] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 79.24 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.5375 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.584 LAYER VIA4 ;
  END inp_a[11]
  PIN inp_a[10] 
    ANTENNAPARTIALMETALAREA 0.07408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001852 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 173.195 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 5.23267 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.38933 LAYER VIA4 ;
  END inp_a[10]
  PIN inp_a[9] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 55.204 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.743 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[9]
  PIN inp_a[8] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 71.484 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.236 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[8]
  PIN inp_a[7] 
    ANTENNAPARTIALMETALAREA 0.0906 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002345 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 99.688 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.8755 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[7]
  PIN inp_a[6] 
    ANTENNAPARTIALMETALAREA 0.07116 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001819 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 109.755 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.26633 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.38933 LAYER VIA4 ;
  END inp_a[6]
  PIN inp_a[5] 
    ANTENNAPARTIALMETALAREA 0.0046 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000155 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 103.81 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.22033 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.43733 LAYER VIA4 ;
  END inp_a[5]
  PIN inp_a[4] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 80.028 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.5115 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.584 LAYER VIA4 ;
  END inp_a[4]
  PIN inp_a[3] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 42.684 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.3125 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.048 LAYER VIA4 ;
  END inp_a[3]
  PIN inp_a[2] 
    ANTENNAPARTIALMETALAREA 0.21232 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005308 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 176.464 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 4.847 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[2]
  PIN inp_a[1] 
    ANTENNAPARTIALMETALAREA 0.203 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005035 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 138.973 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.86317 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.41333 LAYER VIA4 ;
  END inp_a[1]
  PIN inp_a[0] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 92.656 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.964 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[0]
  PIN inp_b[15] 
    ANTENNAPARTIALMETALAREA 0.0838 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002095 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.3544 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0089 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.008 LAYER M5 ; 
    ANTENNAMAXAREACAR 293.244 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 8.42483 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.672 LAYER VIA5 ;
  END inp_b[15]
  PIN inp_b[14] 
    ANTENNAPARTIALMETALAREA 0.04044 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001051 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 136.694 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 4.2165 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.048 LAYER VIA4 ;
  END inp_b[14]
  PIN inp_b[13] 
    ANTENNAPARTIALMETALAREA 0.0814 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002075 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 135.91 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 4.08 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_b[13]
  PIN inp_b[12] 
    ANTENNAPARTIALMETALAREA 0.07116 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001819 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 107.302 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.218 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_b[12]
  PIN inp_b[11] 
    ANTENNAPARTIALMETALAREA 0.02252 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000603 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 108.566 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.3935 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.048 LAYER VIA4 ;
  END inp_b[11]
  PIN inp_b[10] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 51.826 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.678 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.048 LAYER VIA4 ;
  END inp_b[10]
  PIN inp_b[9] 
    ANTENNAPARTIALMETALAREA 0.55836 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.014119 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.005 LAYER M4 ; 
    ANTENNAMAXAREACAR 311.52 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 9.0618 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 5.44 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.5424 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01364 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 371.787 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 10.5774 LAYER M5 ;
    ANTENNAMAXCUTCAR 6.272 LAYER VIA5 ;
  END inp_b[9]
  PIN inp_b[8] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 49.644 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.612 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_b[8]
  PIN inp_b[7] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 50.668 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.644 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_b[7]
  PIN inp_b[6] 
    ANTENNAPARTIALMETALAREA 0.03788 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000987 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 58.764 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.643 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_b[6]
  PIN inp_b[5] 
    ANTENNAPARTIALMETALAREA 0.0646 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001615 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.2552 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00642 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.004 LAYER M5 ; 
    ANTENNAMAXAREACAR 314.154 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 9.211 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.672 LAYER VIA5 ;
  END inp_b[5]
  PIN inp_b[4] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 57.324 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.852 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_b[4]
  PIN inp_b[3] 
    ANTENNAPARTIALMETALAREA 0.0558 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001435 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 111.852 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.19 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_b[3]
  PIN inp_b[2] 
    ANTENNAPARTIALMETALAREA 0.04044 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001051 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 98.828 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.905 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_b[2]
  PIN inp_b[1] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 59.812 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.887 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_b[1]
  PIN inp_b[0] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 59.268 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.896 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_b[0]
  PIN prod[31] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
  END prod[31]
  PIN prod[30] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04672 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001168 LAYER M4 ;
  END prod[30]
  PIN prod[29] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04928 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001232 LAYER M4 ;
  END prod[29]
  PIN prod[28] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001104 LAYER M4 ;
  END prod[28]
  PIN prod[27] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
  END prod[27]
  PIN prod[26] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04928 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001232 LAYER M4 ;
  END prod[26]
  PIN prod[25] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00104 LAYER M4 ;
  END prod[25]
  PIN prod[24] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03136 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000784 LAYER M4 ;
  END prod[24]
  PIN prod[23] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03648 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000912 LAYER M4 ;
  END prod[23]
  PIN prod[22] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03136 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000784 LAYER M4 ;
  END prod[22]
  PIN prod[21] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03648 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000912 LAYER M4 ;
  END prod[21]
  PIN prod[20] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
  END prod[20]
  PIN prod[19] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
  END prod[19]
  PIN prod[18] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
  END prod[18]
  PIN prod[17] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03648 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000912 LAYER M4 ;
  END prod[17]
  PIN prod[16] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03136 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000784 LAYER M4 ;
  END prod[16]
  PIN prod[15] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001104 LAYER M4 ;
  END prod[15]
  PIN prod[14] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[14]
  PIN prod[13] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01856 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000464 LAYER M4 ;
  END prod[13]
  PIN prod[12] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.02368 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000592 LAYER M4 ;
  END prod[12]
  PIN prod[11] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03904 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000976 LAYER M4 ;
  END prod[11]
  PIN prod[10] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001104 LAYER M4 ;
  END prod[10]
  PIN prod[9] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04928 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001232 LAYER M4 ;
  END prod[9]
  PIN prod[8] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.05184 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001296 LAYER M4 ;
  END prod[8]
  PIN prod[7] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00104 LAYER M4 ;
  END prod[7]
  PIN prod[6] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
  END prod[6]
  PIN prod[5] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04672 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001168 LAYER M4 ;
  END prod[5]
  PIN prod[4] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00104 LAYER M4 ;
  END prod[4]
  PIN prod[3] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0544 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00136 LAYER M4 ;
  END prod[3]
  PIN prod[2] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03648 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000912 LAYER M4 ;
  END prod[2]
  PIN prod[1] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03904 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000976 LAYER M4 ;
  END prod[1]
  PIN prod[0] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.10304 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002576 LAYER M4 ;
  END prod[0]
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.0038 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5e-05 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.076 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00194 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M5 ; 
    ANTENNAMAXAREACAR 519.714 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 13.248 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.672 LAYER VIA5 ;
  END clk
  PIN rst 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 55.208 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.718 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END rst
END mult

END LIBRARY
