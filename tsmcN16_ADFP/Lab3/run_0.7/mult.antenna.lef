

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO mult 
  PIN inp_a[15] 
    ANTENNAPARTIALMETALAREA 0.0678 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001695 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.5496 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01378 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M5 ; 
    ANTENNAMAXAREACAR 364.254 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 9.4035 LAYER M5 ;
    ANTENNAMAXCUTCAR 3.872 LAYER VIA5 ;
  END inp_a[15]
  PIN inp_a[14] 
    ANTENNAPARTIALMETALAREA 0.1766 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.004415 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.492 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01234 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M5 ; 
    ANTENNAMAXAREACAR 280.419 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 7.2795 LAYER M5 ;
    ANTENNAMAXCUTCAR 3.36 LAYER VIA5 ;
  END inp_a[14]
  PIN inp_a[13] 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 81.316 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.559 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[13]
  PIN inp_a[12] 
    ANTENNAPARTIALMETALAREA 0.06128 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001532 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 137.69 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 4.1785 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_a[12]
  PIN inp_a[11] 
    ANTENNAPARTIALMETALAREA 0.07116 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001819 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 133.408 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.954 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_a[11]
  PIN inp_a[10] 
    ANTENNAPARTIALMETALAREA 0.05616 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001404 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 189.671 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 5.8125 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_a[10]
  PIN inp_a[9] 
    ANTENNAPARTIALMETALAREA 0.01228 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000347 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 173.472 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 5.406 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.584 LAYER VIA4 ;
  END inp_a[9]
  PIN inp_a[8] 
    ANTENNAPARTIALMETALAREA 0.25804 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.006491 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 182.027 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 5.1195 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.38933 LAYER VIA4 ;
  END inp_a[8]
  PIN inp_a[7] 
    ANTENNAPARTIALMETALAREA 0.12424 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.003146 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.004 LAYER M4 ; 
    ANTENNAMAXAREACAR 168.974 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 5.0955 LAYER M4 ;
    ANTENNAMAXCUTCAR 5.12 LAYER VIA4 ;
  END inp_a[7]
  PIN inp_a[6] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 71.866 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.297 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.048 LAYER VIA4 ;
  END inp_a[6]
  PIN inp_a[5] 
    ANTENNAPARTIALMETALAREA 0.08548 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002217 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 110.663 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.274 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.096 LAYER VIA4 ;
  END inp_a[5]
  PIN inp_a[4] 
    ANTENNAPARTIALMETALAREA 0.02764 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000731 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 58.434 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.85433 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.41333 LAYER VIA4 ;
  END inp_a[4]
  PIN inp_a[3] 
    ANTENNAPARTIALMETALAREA 0.03532 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000923 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 59.8147 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.791 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.38933 LAYER VIA4 ;
  END inp_a[3]
  PIN inp_a[2] 
    ANTENNAPARTIALMETALAREA 0.07628 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001947 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 139.642 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 4.27367 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.38933 LAYER VIA4 ;
  END inp_a[2]
  PIN inp_a[1] 
    ANTENNAPARTIALMETALAREA 0.08652 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002203 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.004 LAYER M4 ; 
    ANTENNAMAXAREACAR 93.998 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.756 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.304 LAYER VIA4 ;
  END inp_a[1]
  PIN inp_a[0] 
    ANTENNAPARTIALMETALAREA 0.04556 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001179 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 83.808 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.367 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[0]
  PIN inp_b[15] 
    ANTENNAPARTIALMETALAREA 0.47288 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.011782 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.007 LAYER M4 ; 
    ANTENNAMAXAREACAR 240.956 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 7.18514 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 5.34857 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.2008 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00506 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 263.267 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 7.74737 LAYER M5 ;
    ANTENNAMAXCUTCAR 5.34857 LAYER VIA5 ;
  END inp_b[15]
  PIN inp_b[14] 
    ANTENNAPARTIALMETALAREA 0.0102 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000255 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.1584 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00404 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 293.018 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 8.54539 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.83657 LAYER VIA5 ;
  END inp_b[14]
  PIN inp_b[13] 
    ANTENNAPARTIALMETALAREA 0.8712 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.02194 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 337.722 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 10.0498 LAYER M4 ;
    ANTENNAMAXCUTCAR 5.12 LAYER VIA4 ;
  END inp_b[13]
  PIN inp_b[12] 
    ANTENNAPARTIALMETALAREA 0.70276 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.017689 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.006 LAYER M4 ; 
    ANTENNAMAXAREACAR 321.345 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 9.41317 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 5.38667 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.1872 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00476 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 342.145 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 9.94206 LAYER M5 ;
    ANTENNAMAXCUTCAR 6.272 LAYER VIA5 ;
  END inp_b[12]
  PIN inp_b[11] 
    ANTENNAPARTIALMETALAREA 0.22548 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005677 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 310.722 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.424 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0032 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 7.296 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.7272 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0183 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 391.522 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 10.4573 LAYER M5 ;
    ANTENNAMAXCUTCAR 7.296 LAYER VIA5 ;
  END inp_b[11]
  PIN inp_b[10] 
    ANTENNAPARTIALMETALAREA 0.2918 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.007415 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.007 LAYER M4 ; 
    ANTENNAMAXAREACAR 286.63 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.67454 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 4.32457 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.22 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00554 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 311.074 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 9.29009 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.672 LAYER VIA5 ;
  END inp_b[10]
  PIN inp_b[9] 
    ANTENNAPARTIALMETALAREA 0.21792 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005528 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 222.079 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 6.89672 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.096 LAYER VIA4 ;
  END inp_b[9]
  PIN inp_b[8] 
    ANTENNAPARTIALMETALAREA 0.39608 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.010022 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 201.558 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 6.10096 LAYER M4 ;
    ANTENNAMAXCUTCAR 5.12 LAYER VIA4 ;
  END inp_b[8]
  PIN inp_b[7] 
    ANTENNAPARTIALMETALAREA 0.34232 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.008678 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.005 LAYER M4 ; 
    ANTENNAMAXAREACAR 275.274 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.3136 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 6.464 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.4152 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01042 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 321.407 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 9.47138 LAYER M5 ;
    ANTENNAMAXCUTCAR 6.464 LAYER VIA5 ;
  END inp_b[7]
  PIN inp_b[6] 
    ANTENNAPARTIALMETALAREA 0.0806 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002015 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.3888 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0098 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 287.434 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 8.61829 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.896 LAYER VIA5 ;
  END inp_b[6]
  PIN inp_b[5] 
    ANTENNAPARTIALMETALAREA 0.2086 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005135 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.7728 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0194 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 256.279 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 7.06289 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.672 LAYER VIA5 ;
  END inp_b[5]
  PIN inp_b[4] 
    ANTENNAPARTIALMETALAREA 0.50208 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.012472 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 282.293 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.54728 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.84 LAYER VIA4 ;
  END inp_b[4]
  PIN inp_b[3] 
    ANTENNAPARTIALMETALAREA 0.70684 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.017831 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.008 LAYER M4 ; 
    ANTENNAMAXAREACAR 446.173 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 13.4939 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 5.32 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.1336 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00338 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 461.017 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 13.8694 LAYER M5 ;
    ANTENNAMAXCUTCAR 5.32 LAYER VIA5 ;
  END inp_b[3]
  PIN inp_b[2] 
    ANTENNAPARTIALMETALAREA 0.88144 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.022036 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 411.5 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 12.3304 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.096 LAYER VIA4 ;
  END inp_b[2]
  PIN inp_b[1] 
    ANTENNAPARTIALMETALAREA 0.1958 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.004815 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.6576 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01652 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 275.135 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 7.14506 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.672 LAYER VIA5 ;
  END inp_b[1]
  PIN inp_b[0] 
    ANTENNAPARTIALMETALAREA 0.17456 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.004444 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 132.424 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.5845 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_b[0]
  PIN prod[31] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0672 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00168 LAYER M4 ;
  END prod[31]
  PIN prod[30] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[30]
  PIN prod[29] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07232 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001808 LAYER M4 ;
  END prod[29]
  PIN prod[28] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07232 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001808 LAYER M4 ;
  END prod[28]
  PIN prod[27] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[27]
  PIN prod[26] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[26]
  PIN prod[25] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07232 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001808 LAYER M4 ;
  END prod[25]
  PIN prod[24] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0672 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00168 LAYER M4 ;
  END prod[24]
  PIN prod[23] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07488 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001872 LAYER M4 ;
  END prod[23]
  PIN prod[22] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0672 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00168 LAYER M4 ;
  END prod[22]
  PIN prod[21] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0672 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00168 LAYER M4 ;
  END prod[21]
  PIN prod[20] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07488 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001872 LAYER M4 ;
  END prod[20]
  PIN prod[19] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.05952 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001488 LAYER M4 ;
  END prod[19]
  PIN prod[18] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0558 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001435 LAYER M4 ;
  END prod[18]
  PIN prod[17] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0032 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 8e-05 LAYER M4 ;
  END prod[17]
  PIN prod[16] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0174 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000475 LAYER M4 ;
  END prod[16]
  PIN prod[15] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
  END prod[15]
  PIN prod[14] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.08396 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002139 LAYER M4 ;
  END prod[14]
  PIN prod[13] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0174 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000475 LAYER M4 ;
  END prod[13]
  PIN prod[12] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04812 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001243 LAYER M4 ;
  END prod[12]
  PIN prod[11] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0558 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001435 LAYER M4 ;
  END prod[11]
  PIN prod[10] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03532 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000923 LAYER M4 ;
  END prod[10]
  PIN prod[9] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0174 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000475 LAYER M4 ;
  END prod[9]
  PIN prod[8] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
  END prod[8]
  PIN prod[7] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
  END prod[7]
  PIN prod[6] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0174 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000475 LAYER M4 ;
  END prod[6]
  PIN prod[5] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0558 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001435 LAYER M4 ;
  END prod[5]
  PIN prod[4] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0558 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001435 LAYER M4 ;
  END prod[4]
  PIN prod[3] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0174 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000475 LAYER M4 ;
  END prod[3]
  PIN prod[2] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00104 LAYER M4 ;
  END prod[2]
  PIN prod[1] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
  END prod[1]
  PIN prod[0] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[0]
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.0038 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5e-05 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.076 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00194 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M5 ; 
    ANTENNAMAXAREACAR 183.38 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 4.785 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.672 LAYER VIA5 ;
  END clk
  PIN rst 
    ANTENNAPARTIALMETALAREA 0.30412 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.007643 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 338.584 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.684 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END rst
END mult

END LIBRARY
