

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO mult 
  PIN inp_a[15] 
    ANTENNAPARTIALMETALAREA 0.0134 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000335 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.5392 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01356 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.007 LAYER M5 ; 
    ANTENNAMAXAREACAR 150.658 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 4.14217 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.32457 LAYER VIA5 ;
  END inp_a[15]
  PIN inp_a[14] 
    ANTENNAPARTIALMETALAREA 0.1702 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.004255 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.4824 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0121 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M5 ; 
    ANTENNAMAXAREACAR 296.762 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 7.839 LAYER M5 ;
    ANTENNAMAXCUTCAR 3.872 LAYER VIA5 ;
  END inp_a[14]
  PIN inp_a[13] 
    ANTENNAPARTIALMETALAREA 0.0942 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002395 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.008 LAYER M4 ; 
    ANTENNAMAXAREACAR 109.725 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.3195 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.224 LAYER VIA4 ;
  END inp_a[13]
  PIN inp_a[12] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 88.106 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.8045 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.048 LAYER VIA4 ;
  END inp_a[12]
  PIN inp_a[11] 
    ANTENNAPARTIALMETALAREA 0.07884 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002011 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.008 LAYER M4 ; 
    ANTENNAMAXAREACAR 108.321 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.28762 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.224 LAYER VIA4 ;
  END inp_a[11]
  PIN inp_a[10] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 158.442 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 5.0345 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.584 LAYER VIA4 ;
  END inp_a[10]
  PIN inp_a[9] 
    ANTENNAPARTIALMETALAREA 0.04044 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001051 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 64.502 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.8765 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.584 LAYER VIA4 ;
  END inp_a[9]
  PIN inp_a[8] 
    ANTENNAPARTIALMETALAREA 0.2374 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005935 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.1528 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00386 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M5 ; 
    ANTENNAMAXAREACAR 173.886 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 4.9725 LAYER M5 ;
    ANTENNAMAXCUTCAR 3.36 LAYER VIA5 ;
  END inp_a[8]
  PIN inp_a[7] 
    ANTENNAPARTIALMETALAREA 0.129 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.003305 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.006 LAYER M4 ; 
    ANTENNAMAXAREACAR 199.913 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 6.09663 LAYER M4 ;
    ANTENNAMAXCUTCAR 5.12 LAYER VIA4 ;
  END inp_a[7]
  PIN inp_a[6] 
    ANTENNAPARTIALMETALAREA 0.04336 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001084 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 65.226 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.97 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_a[6]
  PIN inp_a[5] 
    ANTENNAPARTIALMETALAREA 0.04044 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001051 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 65.8847 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.93383 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.41333 LAYER VIA4 ;
  END inp_a[5]
  PIN inp_a[4] 
    ANTENNAPARTIALMETALAREA 0.04336 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001084 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 65.226 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 1.97 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_a[4]
  PIN inp_a[3] 
    ANTENNAPARTIALMETALAREA 0.408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01036 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.003 LAYER M4 ; 
    ANTENNAMAXAREACAR 210.362 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 5.79233 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 6.67733 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.0888 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00226 LAYER M5 ;
    ANTENNAGATEAREA 0.008 LAYER M5 ; 
    ANTENNAMAXAREACAR 221.462 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 6.07483 LAYER M5 ;
    ANTENNAMAXCUTCAR 6.67733 LAYER VIA5 ;
  END inp_a[3]
  PIN inp_a[2] 
    ANTENNAPARTIALMETALAREA 0.13552 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.003388 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.002 LAYER M4 ; 
    ANTENNAMAXAREACAR 124.314 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.5285 LAYER M4 ;
    ANTENNAMAXCUTCAR 2.56 LAYER VIA4 ;
  END inp_a[2]
  PIN inp_a[1] 
    ANTENNAPARTIALMETALAREA 0.21732 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005433 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.007 LAYER M4 ; 
    ANTENNAMAXAREACAR 113.696 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 3.32614 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.43733 LAYER VIA4 ;
  END inp_a[1]
  PIN inp_a[0] 
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 70.952 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 2.21 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END inp_a[0]
  PIN inp_b[15] 
    ANTENNAPARTIALMETALAREA 0.59272 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.014858 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.005 LAYER M4 ; 
    ANTENNAMAXAREACAR 309.418 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.9876 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 3.392 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.3504 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00884 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 348.351 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 9.96982 LAYER M5 ;
    ANTENNAMAXCUTCAR 5.92 LAYER VIA5 ;
  END inp_b[15]
  PIN inp_b[14] 
    ANTENNAPARTIALMETALAREA 0.55328 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.013752 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 257.342 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 7.732 LAYER M4 ;
    ANTENNAMAXCUTCAR 5.12 LAYER VIA4 ;
  END inp_b[14]
  PIN inp_b[13] 
    ANTENNAPARTIALMETALAREA 0.0838 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002095 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.3576 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00898 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 347.721 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 10.034 LAYER M5 ;
    ANTENNAMAXCUTCAR 5.44 LAYER VIA5 ;
  END inp_b[13]
  PIN inp_b[12] 
    ANTENNAPARTIALMETALAREA 0.76368 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.019252 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.006 LAYER M4 ; 
    ANTENNAMAXAREACAR 241.898 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 6.87367 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 5.38667 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.252 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00634 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 269.898 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 7.57811 LAYER M5 ;
    ANTENNAMAXCUTCAR 5.38667 LAYER VIA5 ;
  END inp_b[12]
  PIN inp_b[11] 
    ANTENNAPARTIALMETALAREA 0.231 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005695 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 309.778 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.24 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0032 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 6.272 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.484 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01222 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 363.556 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 9.59778 LAYER M5 ;
    ANTENNAMAXCUTCAR 6.272 LAYER VIA5 ;
  END inp_b[11]
  PIN inp_b[10] 
    ANTENNAPARTIALMETALAREA 0.37392 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.009468 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.006 LAYER M4 ; 
    ANTENNAMAXAREACAR 272.842 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.24 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0032 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 5.65333 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.2736 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00692 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 303.242 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 9.00889 LAYER M5 ;
    ANTENNAMAXCUTCAR 5.65333 LAYER VIA5 ;
  END inp_b[10]
  PIN inp_b[9] 
    ANTENNAPARTIALMETALAREA 0.27936 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.007064 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.006 LAYER M4 ; 
    ANTENNAMAXAREACAR 229.775 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 6.97533 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 5.38667 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.4536 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01138 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 280.175 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 8.23978 LAYER M5 ;
    ANTENNAMAXCUTCAR 5.38667 LAYER VIA5 ;
  END inp_b[9]
  PIN inp_b[8] 
    ANTENNAPARTIALMETALAREA 0.26912 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.006808 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 154.056 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 4.68516 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.096 LAYER VIA4 ;
  END inp_b[8]
  PIN inp_b[7] 
    ANTENNAPARTIALMETALAREA 0.5384 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01362 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 277.36 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.37858 LAYER M4 ;
    ANTENNAMAXCUTCAR 4.096 LAYER VIA4 ;
  END inp_b[7]
  PIN inp_b[6] 
    ANTENNAPARTIALMETALAREA 0.0774 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001935 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.22 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00554 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 489.58 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 12.8336 LAYER M5 ;
    ANTENNAMAXCUTCAR 5.32 LAYER VIA5 ;
  END inp_b[6]
  PIN inp_b[5] 
    ANTENNAPARTIALMETALAREA 0.1766 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.004335 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.6352 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01596 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 285.236 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 8.206 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.896 LAYER VIA5 ;
  END inp_b[5]
  PIN inp_b[4] 
    ANTENNAPARTIALMETALAREA 0.62288 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.015732 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 266.611 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8 LAYER M4 ;
    ANTENNAMAXCUTCAR 5.12 LAYER VIA4 ;
  END inp_b[4]
  PIN inp_b[3] 
    ANTENNAPARTIALMETALAREA 0.78364 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.019671 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.005 LAYER M4 ; 
    ANTENNAMAXAREACAR 640.658 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 19.2042 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAMAXCUTCAR 8.512 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.0312 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00082 LAYER M5 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 644.125 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 19.2953 LAYER M5 ;
    ANTENNAMAXCUTCAR 8.512 LAYER VIA5 ;
  END inp_b[3]
  PIN inp_b[2] 
    ANTENNAPARTIALMETALAREA 0.2246 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.005535 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.7536 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.01892 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M5 ; 
    ANTENNAMAXAREACAR 278.262 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 7.92526 LAYER M5 ;
    ANTENNAMAXCUTCAR 7.296 LAYER VIA5 ;
  END inp_b[2]
  PIN inp_b[1] 
    ANTENNAPARTIALMETALAREA 0.80952 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.020278 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.009 LAYER M4 ; 
    ANTENNAMAXAREACAR 524.565 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 15.9181 LAYER M4 ;
    ANTENNAMAXCUTCAR 5.12 LAYER VIA4 ;
  END inp_b[1]
  PIN inp_b[0] 
    ANTENNAPARTIALMETALAREA 0.41416 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.010314 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.01 LAYER M4 ; 
    ANTENNAMAXAREACAR 256.591 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 7.7519 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.41333 LAYER VIA4 ;
  END inp_b[0]
  PIN prod[31] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07744 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001936 LAYER M4 ;
  END prod[31]
  PIN prod[30] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[30]
  PIN prod[29] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07744 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001936 LAYER M4 ;
  END prod[29]
  PIN prod[28] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
  END prod[28]
  PIN prod[27] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[27]
  PIN prod[26] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[26]
  PIN prod[25] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07744 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001936 LAYER M4 ;
  END prod[25]
  PIN prod[24] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[24]
  PIN prod[23] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.08 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002 LAYER M4 ;
  END prod[23]
  PIN prod[22] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07488 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001872 LAYER M4 ;
  END prod[22]
  PIN prod[21] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07488 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001872 LAYER M4 ;
  END prod[21]
  PIN prod[20] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.08 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002 LAYER M4 ;
  END prod[20]
  PIN prod[19] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[19]
  PIN prod[18] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07744 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001936 LAYER M4 ;
  END prod[18]
  PIN prod[17] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
  END prod[17]
  PIN prod[16] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03532 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000923 LAYER M4 ;
  END prod[16]
  PIN prod[15] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07884 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.002011 LAYER M4 ;
  END prod[15]
  PIN prod[14] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
  END prod[14]
  PIN prod[13] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0174 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000475 LAYER M4 ;
  END prod[13]
  PIN prod[12] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.07628 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001947 LAYER M4 ;
  END prod[12]
  PIN prod[11] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.06092 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001563 LAYER M4 ;
  END prod[11]
  PIN prod[10] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03532 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000923 LAYER M4 ;
  END prod[10]
  PIN prod[9] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03532 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000923 LAYER M4 ;
  END prod[9]
  PIN prod[8] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
  END prod[8]
  PIN prod[7] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
  END prod[7]
  PIN prod[6] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03532 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000923 LAYER M4 ;
  END prod[6]
  PIN prod[5] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03532 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000923 LAYER M4 ;
  END prod[5]
  PIN prod[4] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.03532 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000923 LAYER M4 ;
  END prod[4]
  PIN prod[3] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.0174 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000475 LAYER M4 ;
  END prod[3]
  PIN prod[2] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.04672 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.001168 LAYER M4 ;
  END prod[2]
  PIN prod[1] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.00408 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000142 LAYER M4 ;
  END prod[1]
  PIN prod[0] 
    ANTENNADIFFAREA 0.001 LAYER M4 ; 
    ANTENNAPARTIALMETALAREA 0.01344 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.000336 LAYER M4 ;
  END prod[0]
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.0038 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5e-05 LAYER M4 ;
    ANTENNAPARTIALCUTAREA 0.0016 LAYER VIA4 ;
    ANTENNAPARTIALMETALAREA 0.076 LAYER M5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.00194 LAYER M5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M5 ; 
    ANTENNAMAXAREACAR 252.5 LAYER M5 ;
    ANTENNAMAXSIDEAREACAR 6.513 LAYER M5 ;
    ANTENNAMAXCUTCAR 4.672 LAYER VIA5 ;
  END clk
  PIN rst 
    ANTENNAPARTIALMETALAREA 0.29132 LAYER M4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.007323 LAYER M4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.001 LAYER M4 ; 
    ANTENNAMAXAREACAR 325.784 LAYER M4 ;
    ANTENNAMAXSIDEAREACAR 8.364 LAYER M4 ;
    ANTENNAMAXCUTCAR 3.072 LAYER VIA4 ;
  END rst
END mult

END LIBRARY
